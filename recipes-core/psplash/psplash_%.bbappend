FILESEXRAPATHS_prepend_poky := "${THISDIR}/files:"
